# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS,HXTAL_VALUE=8000000
  c include: ..\User;..\Hardware;..\Library;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c systick.c main.c
  group Library
    ../Library/: EXTI.c TIMER.c USART0.c
  group Library/configs
    ../Library/: EXTI_config.h TIMER_config.h USART_config.h
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
