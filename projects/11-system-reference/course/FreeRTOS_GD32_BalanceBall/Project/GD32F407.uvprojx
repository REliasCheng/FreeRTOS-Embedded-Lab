# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: .\keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output .\Objects\Project.bin .\Objects\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS,HXTAL_VALUE=8000000
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\SPI;..\Library\I2C;..\Library\USART;..\Hardware;..\Hardware\VL53L0X;..\Hardware\VL53L0X\platform\inc;..\Hardware\VL53L0X\core\inc;..\Hardware\OLED_I2C;..\App;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: App_Balance.c App_Input.c App_OLED.c App_Protocol.c App.h
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Library
    ../Library/I2C/: I2C0.c I2C.c
    ../Library/: EXTI.c TIMER.c
    ../Library/USART/: USART0.c USART.c
  group Library/configs
    ../Library/USART/: USART_config.h
    ../Library/: EXTI_config.h TIMER_config.h
    ../Library/I2C/: I2C_config.h
  group Hardware
    ../Hardware/: bsp_keys.c bsp_servo_motor.c
    ../Hardware/OLED_I2C/: oled.c
  group Hardware/VL53L0X
    ../Hardware/VL53L0X/: bsp_VL53L0X.c vl53l0x_cali.c vl53l0x_gen.c
    ../Hardware/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../Hardware/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group Driver
    ../Driver/: circular_queue.c Protocol.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, Device:Startup 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:I2C 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
