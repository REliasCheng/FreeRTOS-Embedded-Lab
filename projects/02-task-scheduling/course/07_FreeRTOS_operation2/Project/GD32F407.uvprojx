# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS,HXTAL_VALUE=8000000
  c include: ..\User;..\Hardware;..\Library;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c systick.c main.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c
  group Library
    ../Library/: EXTI.c TIMER.c USART0.c
  group Library/configs
    ../Library/: EXTI_config.h TIMER_config.h USART_config.h
  group Hardware
    ../Hardware/: bsp_keys.c
  group FreeRTOS/Core
    ../FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c stream_buffer.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h
