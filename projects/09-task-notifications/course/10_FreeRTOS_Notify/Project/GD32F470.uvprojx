# Keil uVision project GD32F470.uvprojx, settings and files
target Target (6210000::V6.21::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,SYS_SUPPORT_OS,__FPU_PRESENT=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Hardware;..\Middleware;..\Hardware\spi_oled;..\Middleware\I2C;..\Middleware\SPI;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Hardware
    ../Hardware/: keys.c
  group Middleware
    ../Middleware/: USART0.c
  group FreeRTOS/Core
    ../FreeRTOS/: list.c queue.c tasks.c event_groups.c stream_buffer.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:ADC 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:FWDGT 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:I2C 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:RTC 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2, Device:StdPeripherals:WWDGT 3.0.2
